
/*******************************************************************
* Converte un numero da intero in stringa di caratteri             *
*								                                   *
********************************************************************/
void itoa(int n,char s[])
{
	int i,a ;
	if (n/100)
		a=2;
	else if (n/10)
		a=1;
	else 
		a=0;
	i=a;

	do
	{
		s[i--]= n%10 + '0';
	}while ((n/=10)>0);

	s[a+1]='\0';
}
/*------------------------ eof itoa ------------------------------*/

/*******************************************************************
*                Converte un numero da decimale in BCD             *
********************************************************************/
unsigned char dec_bcd(char ndec)
{
	unsigned char i=0;
	if (ndec>9){
		i=(ndec/10)<<4;
		i=i|(ndec%10);
	}
	else
		i=ndec;
	return i;
}
/*------------------------ eof itoa ------------------------------*/

/*******************************************************************
*                Converte un numero da decimale in BCD             *
********************************************************************/
unsigned char bcd_dec(char nbcd)
{
	nbcd=(nbcd&0b00001111)+(nbcd>>4)*10;
	return nbcd;
}
/*------------------------ eof itoa ------------------------------*/
